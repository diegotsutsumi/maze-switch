# IAR project Maze.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Maze.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group inc
    ./: app.h bsp_config.h memory.h stm32f10x_it.h sys_init.h sys_tasks.h user_interface.h
  group library/inc
    ./: core_cm3.h misc.h stm32f10x.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_tim.h system_stm32f10x.h
  group library/src
    ./: core_cm3.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c system_stm32f10x.c
  group src
    ./: app.c bsp_config.c main.c memory.c stm32f10x_it.c sys_init.c sys_tasks.c user_interface.c
